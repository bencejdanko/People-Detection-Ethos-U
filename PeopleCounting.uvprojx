# Keil uVision project PeopleCounting.uvprojx, settings and files
target ObjectDetection (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.4-rc.3
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: ObjectDetection
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\release\@L.bin"
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: NVT_VECTOR_ON_FLASH, TF_LITE_STATIC_MEMORY, ARM_MATH_DSP, ARM_NPU, ACTIVATION_BUF_SZ=0x000B0000
  c include: M55M1BSP\Library\CMSIS\Core\Include;M55M1BSP\Library\Device\Nuvoton\M55M1\Include;M55M1BSP\Library\CMSIS\DSP\Include;M55M1BSP\Library\StdDriver\inc;M55M1BSP\Library\StdDriver\inc\npu;M55M1BSP\ThirdParty\openmv\omv\imlib;M55M1BSP\ThirdParty\openmv\omv\alloc;M55M1BSP\ThirdParty\openmv\omv\common;M55M1BSP\ThirdParty\openmv\omv\Lib;M55M1BSP\ThirdParty\tflite_micro;M55M1BSP\ThirdParty\tflite_micro\_deps\tensorflow-flatbuffers-src\include;M55M1BSP\ThirdParty\ml-embedded-evaluation-kit\source\application\api\common\include;M55M1BSP\ThirdParty\ml-embedded-evaluation-kit\source\log\include;M55M1BSP\ThirdParty\ml-embedded-evaluation-kit\source\math\include;M55M1BSP\ThirdParty\ml-embedded-evaluation-kit\source\application\main\include;M55M1BSP\ThirdParty\ml-embedded-evaluation-kit\source\profiler\include;Device\include;model;NPU\include;ProfilerCounter\include;.;M55M1BSP\ThirdParty\tflite_micro\_deps\tensorflow-gemlowp-src;M55M1BSP\ThirdParty\FatFs\source;M55M1BSP\ThirdParty\FreeRTOS\Source\include;M55M1BSP\ThirdParty\FreeRTOS\Source\portable\GCC\ARM_CM55_NTZ\non_secure
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\M55M1.scatter
  group CMSIS
    M55M1BSP/Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Driver
    M55M1BSP/Library/StdDriver/src/: uart.c retarget.c ccap.c clk.c sys.c gpio.c ebi.c spim_hyper.c sdh.c spi.c hsusbd.c pdma.c
    M55M1BSP/Library/StdDriver/src/npu/: ethosu_device_u55_u65.c ethosu_driver.c ethosu_pmu.c
  group Application
    ./: BoardInit.cpp main.cpp wifi_push.cpp mpu_config_M55M1.h ModelFileReader.c
    model/: PostProcessor.cpp
  group Lib
    M55M1BSP/Library/CMSIS/Lib/KEIL/: cmsis_dsp.lib cmsis_nn.lib
    M55M1BSP/ThirdParty/tflite_micro/Lib/: tflu.lib
    M55M1BSP/ThirdParty/openmv/omv/Lib/: omv.lib
  group Model
    model/: InferenceModel.cpp
  group ArmMLApi
    M55M1BSP/ThirdParty/ml-embedded-evaluation-kit/source/application/api/common/source/: Model.cc TensorFlowLiteMicro.cc
    M55M1BSP/ThirdParty/ml-embedded-evaluation-kit/source/math/: PlatformMath.cc
    M55M1BSP/ThirdParty/ml-embedded-evaluation-kit/source/profiler/: Profiler.cc
  group NPU
    NPU/: ethosu_cpu_cache.c ethosu_npu_init.c ethosu_profiler.c
  group ProfilerCounter
    ProfilerCounter/: pmu_counter.c
  group Device
    Device/ImageSensor/: ImageSensor.c
    Device/ImageSensor/Sensor/: Sensor_HM1055.c SWI2C.c
    Device/Display/: Display.c Font8_16.c drv_pdma.c
    Device/Display/LCD/: LCD_FSA506.c LCD_ILI9341.c LCD_LT7381.c
    Device/HyperRAM/: hyperram_code.c
    Device/SDCard/: sdglue.c
    Device/UVC/: descriptors.c UVC.c
    M55M1BSP/Library/Storage/: diskio_SDH.c
  group FatFS
    M55M1BSP/ThirdParty/FatFs/source/: ff.c ffunicode.c
  group FreeRTOS
    M55M1BSP/ThirdParty/FreeRTOS/Source/: tasks.c queue.c list.c timers.c event_groups.c
    M55M1BSP/ThirdParty/FreeRTOS/Source/portable/GCC/ARM_CM55_NTZ/non_secure/: port.c portasm.c
    M55M1BSP/ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_4.c
